# Keil uVision project WS2812B_BluePill.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WS2812B_BluePill
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD,WS2812B_OUTPUT_PAx=1
  c include: ..\WS2812B_BluePill;.\ws2812b
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: main.c
  group ws2812b
    ./ws2812b/: ws2812b.c ws2812b.h ws2812b_config.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
