# Keil uVision project 74HC165.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS_I2C_EEPROM +hex
  AfterMake: fromelf --bin --output .\Objects\CMSIS_I2C_EEPROM.bin .\Objects\CMSIS_I2C_EEPROM.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,STM32F10X_MD
  c include: .\user\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/src/: main.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
